#include "weather_icons.h"
#include <TFT_eSPI.h>
extern TFT_eSPI tft;

// 16x16 pixel-art weather glyphs, stored as row bitmasks (MSB-left).
// Same encoding as Display::drawLogo() in display.cpp.

//  ☀ Sun — radiating circle
//  ................
//  ......#..#......
//  ...#..#..#..#...
//  ....#.####.#....
//  ..#..######..#..
//  .....######.....
//  .#.###....###.#.
//  ..####....####..
//  ..####....####..
//  .#.###....###.#.
//  .....######.....
//  ..#..######..#..
//  ....#.####.#....
//  ...#..#..#..#...
//  ......#..#......
//  ................
static const uint16_t ICON_SUN[16] = {
    0x0000, 0x0240, 0x1248, 0x09E4,
    0x23E2, 0x07E0, 0x5E3D, 0x3C3C,
    0x3C3C, 0x5E3D, 0x07E0, 0x23E2,
    0x09E4, 0x1248, 0x0240, 0x0000,
};

//  ⛅ Partly cloudy — small sun top-right, cloud bottom-left
//  ................
//  ..........#.....
//  .........#.#....
//  ..........#.....
//  .......#.###.#..
//  ........#####...
//  ...##..#.###.#..
//  ..#..#..........
//  .#....#.........
//  .#....#.........
//  ..####..........
//  ................
//  ................
//  ................
//  ................
//  ................
static const uint16_t ICON_PARTCLOUD[16] = {
    0x0000, 0x0020, 0x0050, 0x0020,
    0x012E, 0x00FC, 0x0C5E, 0x1400,
    0x2200, 0x2200, 0x0F00, 0x0000,
    0x0000, 0x0000, 0x0000, 0x0000,
};

//  ☁ Cloud — full puffy cloud
//  ................
//  ................
//  ................
//  .....####.......
//  ....#....#......
//  ...#......#.....
//  ..#..####..#....
//  .#..#....#..#...
//  .#..........#...
//  ..##########....
//  ................
//  ................
//  ................
//  ................
//  ................
//  ................
static const uint16_t ICON_CLOUD[16] = {
    0x0000, 0x0000, 0x0000, 0x07C0,
    0x0820, 0x1010, 0x2788, 0x4824,
    0x4004, 0x3FF8, 0x0000, 0x0000,
    0x0000, 0x0000, 0x0000, 0x0000,
};

//  🌫 Fog — stacked horizontal lines
//  ................
//  ................
//  ................
//  ................
//  ..############..
//  ................
//  ...##########...
//  ................
//  ..############..
//  ................
//  ...##########...
//  ................
//  ..############..
//  ................
//  ................
//  ................
static const uint16_t ICON_FOG[16] = {
    0x0000, 0x0000, 0x0000, 0x0000,
    0x3FFC, 0x0000, 0x1FF8, 0x0000,
    0x3FFC, 0x0000, 0x1FF8, 0x0000,
    0x3FFC, 0x0000, 0x0000, 0x0000,
};

//  🌧 Drizzle — cloud with small dots below
//  ................
//  ................
//  .....####.......
//  ...##....##.....
//  ..#..####..#....
//  .#..#....#..#...
//  .#..........#...
//  ..##########....
//  ................
//  ...#...#...#....
//  ................
//  ..#...#...#.....
//  ................
//  ................
//  ................
//  ................
static const uint16_t ICON_DRIZZLE[16] = {
    0x0000, 0x0000, 0x07C0, 0x1C30,
    0x2788, 0x4824, 0x4004, 0x3FF8,
    0x0000, 0x1110, 0x0000, 0x2220,
    0x0000, 0x0000, 0x0000, 0x0000,
};

//  🌧 Rain — cloud with vertical streaks
//  ................
//  ................
//  .....####.......
//  ...##....##.....
//  ..#..####..#....
//  .#..#....#..#...
//  .#..........#...
//  ..##########....
//  ................
//  ...#..#..#......
//  ...#..#..#......
//  ....#..#..#.....
//  ....#..#..#.....
//  ................
//  ................
//  ................
static const uint16_t ICON_RAIN[16] = {
    0x0000, 0x0000, 0x07C0, 0x1C30,
    0x2788, 0x4824, 0x4004, 0x3FF8,
    0x0000, 0x1240, 0x1240, 0x0920,
    0x0920, 0x0000, 0x0000, 0x0000,
};

//  ❄ Snow — asterisk/snowflake
//  ................
//  ................
//  ................
//  .......##.......
//  ...#...##...#...
//  ....#..##..#....
//  .....#.##.#.....
//  ..############..
//  ..############..
//  .....#.##.#.....
//  ....#..##..#....
//  ...#...##...#...
//  .......##.......
//  ................
//  ................
//  ................
static const uint16_t ICON_SNOW[16] = {
    0x0000, 0x0000, 0x0000, 0x0180,
    0x1188, 0x0984, 0x05A0, 0x3FFC,
    0x3FFC, 0x05A0, 0x0984, 0x1188,
    0x0180, 0x0000, 0x0000, 0x0000,
};

//  ⛈ Thunder — cloud with lightning bolt
//  ................
//  .....####.......
//  ...##....##.....
//  ..#..####..#....
//  .#..#....#..#...
//  .#..........#...
//  ..##########....
//  ......##........
//  .....##.........
//  ....####........
//  ......##........
//  .....##.........
//  ....##..........
//  ................
//  ................
//  ................
static const uint16_t ICON_THUNDER[16] = {
    0x0000, 0x07C0, 0x1C30, 0x2788,
    0x4824, 0x4004, 0x3FF8, 0x0300,
    0x0600, 0x0F00, 0x0300, 0x0600,
    0x0C00, 0x0000, 0x0000, 0x0000,
};

static const uint16_t* iconFor(uint8_t wmoCode) {
    if (wmoCode == 0)                       return ICON_SUN;
    if (wmoCode == 1 || wmoCode == 2)       return ICON_PARTCLOUD;
    if (wmoCode == 3)                       return ICON_CLOUD;
    if (wmoCode == 45 || wmoCode == 48)     return ICON_FOG;
    if (wmoCode >= 51 && wmoCode <= 57)     return ICON_DRIZZLE;
    if (wmoCode >= 61 && wmoCode <= 67)     return ICON_RAIN;
    if (wmoCode >= 71 && wmoCode <= 77)     return ICON_SNOW;
    if (wmoCode >= 80 && wmoCode <= 82)     return ICON_RAIN;
    if (wmoCode == 85 || wmoCode == 86)     return ICON_SNOW;
    if (wmoCode >= 95 && wmoCode <= 99)     return ICON_THUNDER;
    return ICON_CLOUD;
}

void WeatherIcon::draw(int x, int y, uint8_t wmoCode, uint16_t color, int scale) {
    const uint16_t* rows = iconFor(wmoCode);
    for (int row = 0; row < 16; row++) {
        uint16_t bits = rows[row];
        if (!bits) continue;
        for (int col = 0; col < 16; col++) {
            if (bits & (1 << (15 - col))) {
                if (scale <= 1)
                    tft.drawPixel(x + col, y + row, color);
                else
                    tft.fillRect(x + col * scale, y + row * scale, scale, scale, color);
            }
        }
    }
}
